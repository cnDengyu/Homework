# Keil uVision project 51MCU.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51MCU +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 51MCU.c showtime.c onClear.c onLoad.c onPause.c onResume.c onSave.c onStart.c onStop.c timerModule.c
